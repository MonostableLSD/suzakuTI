# Keil uVision project driverlib.uvprojx, settings and files
target driverlib (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: driverlib (library)
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk
  c misc: --c99
  c include: ..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: adc.c aes.c can.c comp.c cpu.c crc.c des.c eeprom.c emac.c epi.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c lcd.c mpu.c onewire.c pwm.c qei.c shamd5.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
  group Documentation
    ./: readme.txt
software components: CMSIS:CORE 5.0.1

# Keil uVision project suzakuTI.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: suzakuTI +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c include: ..\suzakuCode;.\driverlib
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\Objects\suzakuTI.sct
  group APP
    ./: suzakuMain.c userDefine.h userVariables.c suzakuPID.c suzakuFlightCtrl.c suzakuCal.c
  group BSP
    ./: initializers.c interrupts.c ESC_PWM.c JY901.c LED.c EEPROM.c
    ./ANO/: Ano_OF.c
  group Lib
    ./driverlib/rvmdk/: driverlib.lib
  group readme
    ./: readme.txt
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.1
